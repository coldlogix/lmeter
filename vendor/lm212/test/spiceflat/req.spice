* Generated by Xic from file db_luk1tff01 (FLATTENED BY HAND)
.tran 1ps 1000ps
I0 0 8
I1 0 9
I2 0 1
L0 10 2 4.26pH
L1 9 14 5.2pH
L2 2 9 4.68pH
L3 1 0 4.0pH
L4 4 6 1.95pH
L5 6 8 0.52pH
L6 8 3 1.04pH
LP0 5 10 0.55pH
LP1 7 11 2.99pH
LP2 2 11 0.68pH
LP3 12 0 0.05pH
LP4 13 0 0.10pH
P0 4 0
R0 14 15 1o
R1 14 0 2.36o
V0 0 15
B0 11 13 100 jjluk1 area=2.04
RS0 11 13 2.36o
B1 9 0 101 jjluk1 area=2.04
RS1 9 0 1.95o
B2 10 12 102 jjluk1 area=1.31
RS2 10 12 3.67o
B3 3 7 103 jjluk1 area=1.0
RS3 3 7 1.31o
B4 6 0 104 jjluk1 area=2.1
RS4 6 0 2.69o
B5 3 5 105 jjluk1 area=2.46
RS5 3 5 1.79o
