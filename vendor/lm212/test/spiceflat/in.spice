* Generated by Xic from file db_luk1tff01
.tran 1ps 1000ps
I0 0 8
I1 0 9
I2 0 1
L0 10 2 4.26pH
L1 9 14 5.2pH
L2 2 9 4.68pH
L3 1 0 4.0pH
L4 4 6 1.95pH
L5 6 8 0.52pH
L6 8 3 1.04pH
LP0 5 10 0.55pH
LP1 7 11 2.99pH
LP2 2 11 0.68pH
LP3 12 0 0.05pH
LP4 13 0 0.10pH
P0 4 0
R0 14 15 1o
R1 14 0 2.36o
V0 0 15
X0 11 13 ak_luk1jj06
X1 9 0 ak_luk1jj06
X2 10 12 ak_luk1jj02
X3 3 7 ak_luk1jj00
X4 6 0 ak_luk1jj09
X5 3 5 ak_luk1jj08
.subckt ak_luk1jj06 2 1
B0 2 1 3 jjluk1 area=2.04
R0 2 1 2.36o
.ends ak_luk1jj06
.subckt ak_luk1jj08 2 1
B0 2 1 3 jjluk1 area=2.46
R0 2 1 1.95o
.ends ak_luk1jj08
.subckt ak_luk1jj09 2 1
B0 2 1 3 jjluk1 area=2.69
R0 2 1 1.79o
.ends ak_luk1jj09
.subckt ak_luk1jj00 2 1
B0 2 1 3 jjluk1 area=1.0
R0 2 1 4.8o
.ends ak_luk1jj00
.subckt ak_luk1jj02 2 1
B0 2 1 3 jjluk1 area=1.31
R0 2 1 3.67o
.ends ak_luk1jj02
