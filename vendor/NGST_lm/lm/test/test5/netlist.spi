* Generated by Xic from file dcsfqlay5
I0 0 13
I1 0 12
J0 11 14 19 jj2500 area=1.0
J1 10 7 20 jj2500 area=.86
J2 6 15 21 jj2500 area=.7
J3 15 0 22 jj2500 area=.86
J4 9 4 23 jj2500 area=1.0
J5 3 16 24 jj2500 area=.86
J6 2 17 25 jj2500 area=1.0
J7 1 18 26 jj2500 area=1.2
L0 10 9 .8ph
L1 12 5 5ph
L10 15 7 2.5ph
L11 0 6 5ph
L12 3 4 1.6ph
L13 4 2 1.2ph
L14 2 5 1.6ph
L15 5 1 1.4ph
L16 0 16 .1ph
L17 0 17 .1ph
L18 0 18 .1ph
L2 7 3 2ph
L3 13 8 5ph
L4 10 0 .3ph
L5 8 10 .2ph
L6 11 8 .1ph
L7 11 0 .6ph
L8 9 0 .3ph
L9 15 14 .05ph
.model jj2500 jj(rtype=1, cct=1, icon=10m, vg=2.8m, delv=0.08m,
+ icrit=0.28m, r0=30, rn=1.64706, cap=0.4337p)
*Nb 2500 A/cm2   area = 11.2 square microns
*Normalized Area = 1.0 => 0.28mA

.save @I0[c]
.save @I1[c]
